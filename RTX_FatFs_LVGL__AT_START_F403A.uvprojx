# Keil uVision project RTX_FatFs_LVGL__AT_START_F403A.uvprojx, settings and files
target AT32F403A_Debug (6240000::V6.24::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTX_FatFs_LVGL__AT_START_F403A
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\MyDriver;.\FatFs;.\MyUI;.\USBDevice
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group Src
    ./Src/: main.c stdout_user.c
  group MyUI
    ./MyUI/: my_gui.c
  group MyDriver
    ./MyDriver/: system.c delay.c encoder_ec11.c fan_ss6285l.c flash_en25qh128a.c sensor_aht20.c oled_ssd1306.c file_system.c led.c calender_rtc.c usbdevice.c button.c voltage_adc.c
  group FatFs
    ./FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group USBDevice
    ./USBDevice/: custom_hid_class.c custom_hid_desc.c usbd_core.c usbd_int.c usbd_sdr.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:OS Interface:CMSIS-RTOS2 2.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Device:Startup 2.0.0, Device:at32f403a_407_conf 2.0.0, Device:at32f403a_407_firmware_library:acc 2.0.0, Device:at32f403a_407_firmware_library:adc 2.0.0, Device:at32f403a_407_firmware_library:bpr 2.0.0, Device:at32f403a_407_firmware_library:crm 2.0.0, Device:at32f403a_407_firmware_library:debug 2.0.0, Device:at32f403a_407_firmware_library:dma 2.0.0, Device:at32f403a_407_firmware_library:exint 2.0.0, Device:at32f403a_407_firmware_library:flash 2.0.0, Device:at32f403a_407_firmware_library:gpio 2.0.0, Device:at32f403a_407_firmware_library:i2c 2.0.0, Device:at32f403a_407_firmware_library:misc 2.0.0, Device:at32f403a_407_firmware_library:pwc 2.0.0, Device:at32f403a_407_firmware_library:rtc 2.0.0, Device:at32f403a_407_firmware_library:spi 2.0.0, Device:at32f403a_407_firmware_library:tmr 2.0.0, Device:at32f403a_407_firmware_library:usart 2.0.0, Device:at32f403a_407_firmware_library:usb 2.0.0, LVGL:Essential 9.3.0, LVGL:Libraries and Others:File Explorer 9.3.0, LVGL:Libraries and Others:Lib Filesystem 9.3.0, LVGL:OS Abstraction Layer 9.3.0, LVGL:Porting:Display 9.3.0, LVGL:Porting:Input 9.3.0
